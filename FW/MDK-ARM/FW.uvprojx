# Keil uVision project FW.uvprojx, settings and files
target FW (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: FW +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F205xx
  c include: ../Core/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c stm32f2xx_it.c stm32f2xx_hal_msp.c lis2dh12_reg.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_i2c.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.3.0
